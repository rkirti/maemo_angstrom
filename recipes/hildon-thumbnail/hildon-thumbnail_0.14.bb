DEPENDS += "libosso gnome-vfs gconf gtk+ glib-2.0"
PR = "r1"

SRC_URI = "http://repository.maemo.org/pool/diablo/free/h/${PN}/${PN}_${PV}.tar.gz"

require hildon-thumbnail.inc
