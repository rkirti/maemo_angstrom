require mce-dev.inc

PR = "r0"

SRC_URI = "http://repository.maemo.org/pool/diablo/free/m/mce-dev/mce-dev_${PV}.tar.gz"


